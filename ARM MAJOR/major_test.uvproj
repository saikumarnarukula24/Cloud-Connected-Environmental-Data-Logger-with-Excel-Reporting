# Keil uVision project major_test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: major_test +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s 24c01.c adc.c adc_rtc_main.c cust_lcd.c delay.c esp01.c esp01_call.c i2c.c interrupt.c keypad.c lcd_driver.c menu_new.c rtc.c smoke.c uart.c uart_main.c
